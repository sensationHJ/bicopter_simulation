Commit message: try fix urdf but cant see rostopics

File: bicopter_ws/src/bicopt-v40/urdf/bicopt-v40.urdf (robot description, URDF)
Before this commit: robot bicopt-v40, 5 links, 4 joints
Joints:
- joint mot0: limit effort=100 velocity=100 -> (none)
